# IAR project CDC_Standalone_Appli.ewp, settings and files
configuration CDC_Standalone_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S3L8 ST STM32H7S3L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx; USE_FULL_LL_DRIVER; USBPD_PORT_COUNT=1; _SNK; USBPDCORE_LIB_NO_PD; TCPP0203_SUPPORT
  ICCARM.CCIncludePath2: ../../Appli/Inc; ../../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo; ./../../../../../Drivers/BSP/Components/tcpp0203; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/STM32H7RSxx_HAL_Driver/Inc; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_USBPD_Library/Core/inc; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/inc; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_USB_Device_Library/Core/Inc; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_Standalone_Appli.hex
  ILINK.IlinkOutputFile: CDC_Standalone_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_ROMxspi2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Appli
    ../../Appli/Src/: main.c usbpd.c usbpd_dpm_user.c usbpd_dpm_core.c usbpd_pwr_user.c usbpd_pwr_if.c usbpd_usb_if.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
  group Drivers/BSP/STM32H7RSxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo/: stm32h7rsxx_nucleo.c stm32h7rsxx_nucleo_bus.c stm32h7rsxx_nucleo_usbpd_pwr.c
  group Drivers/STM32H7RSxx_HAL_Driver
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_exti.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_ll_usb.c stm32h7rsxx_ll_utils.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_ll_ucpd.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_dma.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_ll_tim.c
  group Middlewares/STM32_USBPD_Library
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM7_wc32.a
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c
  group Middlewares/STM32_USB_Device_Library
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
