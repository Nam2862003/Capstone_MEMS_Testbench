# IAR project CDC_Standalone_Boot.ewp, settings and files
configuration CDC_Standalone_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S3L8 ST STM32H7S3L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx
  ICCARM.CCIncludePath2: ../../Boot/Inc; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/STM32H7RSxx_HAL_Driver/Inc; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/boot; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/sal; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/psram; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/sdcard; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/user; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_Standalone_Boot.hex
  ILINK.IlinkOutputFile: CDC_Standalone_Boot.out
  ILINK.IlinkIcfFile: stm32h7s3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Boot
    ../../Boot/Src/: main.c extmem_manager.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Boot/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_exti.c stm32h7rsxx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_xip.c
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c stm32_sal_sd.c
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_H7RS_V1.3.0/Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
